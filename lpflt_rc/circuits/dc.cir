* gnetlist -g spice-sdb -o ./netlist/dc.net ./schematic/dc.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*==============  Begin SPICE netlist of main design ============
Vi Ni 0 DC 1V
C1 No 0 1u
R1 Ni No 1k
.control
dc Vi 1V 10V 0.1V
run
wrdata ./data/dc v(No)
.endc
.END
