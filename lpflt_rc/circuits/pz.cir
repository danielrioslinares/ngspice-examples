* gnetlist -g spice-sdb -o ./netlist/pz.net ./schematic/pz.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*==============  Begin SPICE netlist of main design ============
Vi Ni 0 dc 0 ac 1
C1 No 0 1u
R1 Ni No 1k
.control
pz Ni 0 No 0 VOL POL
run
wrdata ./data/pz all
.endc
.END
